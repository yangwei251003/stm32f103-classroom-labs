# Keil uVision project project.uvprojx, settings and files
target Target 1 (6090000::V6.9::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: oled-digits
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c misc: -D__INLINE=inline "-D__DSB()=__builtin_arm_dsb(0xF)"
  c include: ../common;../../external/STM32F10x/Library;../../external/STM32F10x/Startup
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Classroom software build
    ./: main.c
    ../common/: delay.c delay.h stm32f10x_conf.h
    ../../external/STM32F10x/Library/: stm32f10x_gpio.c stm32f10x_rcc.c
    ../../external/STM32F10x/Startup/: system_stm32f10x.c startup_stm32f10x_md.s
